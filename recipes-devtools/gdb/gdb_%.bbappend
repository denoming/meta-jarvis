PACKAGECONFIG:append = " readline python babeltrace xz "