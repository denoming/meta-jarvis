PACKAGECONFIG:append = " libav opencv"
